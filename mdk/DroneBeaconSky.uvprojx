# Keil uVision project DroneBeaconSky.uvprojx, settings and files
target DroneBeaconSky (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DroneBeaconSky
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\source\core;..\source\mcu\inc;..\source\driver;..\source\midware;..\source\app
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group core
    ../source/core/: interrupts_hc32l110.c system_hc32l110.c main.c
    ./: startup_hc32l110.s
  group mcu
    ../source/mcu/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
  group driver
    ../source/driver/: i2c_hal.c spl0601.c mcu_hal.c lpuart_hal.c
software components: CMSIS:CORE 5.4.0
